# IAR project E3_ref_gateway_E3420_xip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; CFG_XIP; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3420; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; NO_STDLIB; DISABLE_MCAL_ASR_VER_CHECK; DISABLE_MCAL_SW_VER_CHECK
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\..\..\arch\armv7-r\; ..\..\..\soc\; ..\..\..\driver; ..\..\..\driver\gic\include; ..\..\..\driver\gic; ..\..\..\driver\gic\common; ..\..\..\driver\gic\lib; ..\..\..\driver\gic\v2; ..\..\..\driver\uart; ..\..\..\driver\uart\sdrv_uart; ..\..\..\service\; ..\..\..\test_suite; ..\..\..\include; ..\..\..\include\common; ..\..\..\include\drivers; ..\..\..\Mcal_Cfg; ..\..\..\Mcal_Cfg\sf\include; ..\..\..\Mcal_Cfg\sf; ..\..\..\Mcal_Cfg\E3_ref_gateway_E3420; ..\..\..\mcal\Lib_TS_T01D20M1I4R0\include; ..\..\..\mcal\Firewall_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mcu_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mcu_TS_T01D20M1I4R0\include\taishan; ..\..\..\mcal\Rte_TS_T01D20M1I4R0\include; ..\..\..\mcal\Gpt_TS_T01D20M1I4R0\include; ..\..\..\mcal\Port_TS_T01D20M1I4R0\include; ..\..\..\mcal\Dio_TS_T01D20M1I4R0\include; ..\..\..\mcal\Dma_TS_T01D20M1I4R0\include; ..\..\..\mcal\IOExp\include; ..\..\..\mcal\CanTrcv\include; ..\..\..\mcal\Wdg_TS_T01D20M1I4R0\include; ..\..\..\mcal\Pwm_TS_T01D20M1I4R0\include; ..\..\..\mcal\Icu_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mailbox_TS_T01D20M1I4R0\include; ..\..\..\mcal\Adc_TS_T01D20M1I4R0\include; ..\..\..\mcal\Crypto_TS_T01D20M1I4R0\include; ..\..\..\mcal\Can_TS_T01D20M1I4R0\include; ..\..\..\mcal\Lin_TS_T01D20M1I4R0\include; ..\..\..\mcal\LinIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\Sent_TS_T01D20M1I4R0\include; ..\..\..\mcal\Spi_TS_T01D20M1I4R0\include; ..\..\..\mcal\I2c_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fls_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fee_TS_T01D20M1I4R0\include; ..\..\..\mcal\Eth_TS_T01D20M1I4R0\include; ..\..\..\mcal\EthTrcv_TS_T01D20M1I4R0\include; ..\..\..\mcal\EthIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\RebootService\include; ..\..\..\mcal\IrqM_TS_T01D20M1I4R0\include; ..\..\..\mcal\Xtrg_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fr_TS_T01D20M1I4R0\include; ..\..\..\test_suite\demo\mc\Motor_Lib_TS_T01D20M1I4R0\Inc; ..\..\..\test_suite\demo\mc\Motor_Lib; ..\..\..\test_suite\demo\mc; ..\..\..\driver\lld; ..\..\..\driver\pwm; ..\..\..\driver\btm; ..\..\..\driver\spi; ..\..\..\driver\clk; ..\..\..\driver\i2c; ..\..\..\driver\sbc; ..\..\..\driver\adc; ..\..\..\driver\Epu; ..\..\..\driver\timer; ..\..\..\Mcal_Cfg\E3_ref_gateway_E3420\output\include; ..\..\..\soc\taishan\include; ..\..\..\AUTOSAR_STACK\BSW\BSWConfig; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\OS\arch\driver; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\OS\arch; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\OS\kernel; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\BswM; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\EcuM; ..\..\..\AUTOSAR_STACK\RTE\StaticCode\Rte_SchM; ..\..\..\AUTOSAR_STACK\RTE\StaticCode\SchM; ..\..\..\AUTOSAR_STACK\BSW\CommonInclude; ..\..\..\AUTOSAR_STACK\BSW\Libraries\FreeRTimer; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\ComM; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\Det; ..\..\..\Cdd; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Com; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\PDUR; ..\..\..\AUTOSAR_STACK\BSW\Communication\LIN\LinIf; ..\..\..\AUTOSAR_STACK\BSW\Communication\LIN\LinSM; ..\..\..\AUTOSAR_STACK\BSW\Communication\CAN\CanIf; ..\..\..\AUTOSAR_STACK\BSW\Communication\CAN\CanSM; ..\..\..\Cdd\AD-CD4067; ..\..\..\Cdd\TCA9539; ..\..\..\Cdd\TCA6424; ..\..\..\driver\HighSide; ..\..\..\driver\ioexp; ..\..\..\driver\HSSwitch; ..\..\..\driver\TLE8108EM; ..\..\..\AUTOSAR_STACK\ASW; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Xcp; ..\..\..\AUTOSAR_STACK\ASW\XcpDataTest; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\NmIf; ..\..\..\AUTOSAR_STACK\BSW\Communication\CAN\CanNm; ..\..\..\AUTOSAR_STACK\BSW\Communication\CAN\CanTp; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Dcm; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Dcm\DcmDsl; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Dcm\DcmDsd; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Dcm\DcmDsp; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Dcm\DcmDsp\UDS; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\Dem; ..\..\..\driver\Audio; ..\..\..\driver\HBridge; ..\..\..\driver\RF; ..\..\..\driver\TLE94103; ..\..\..\AUTOSAR_STACK\BSW\Memory\Ea; ..\..\..\AUTOSAR_STACK\BSW\Memory\Eep; ..\..\..\AUTOSAR_STACK\BSW\Memory\MemIf; ..\..\..\AUTOSAR_STACK\BSW\Memory\NvM; ..\..\..\AUTOSAR_STACK\BSW\Libraries\Crc; ..\..\..\AUTOSAR_STACK\BSW\Communication\Common\Dcm\Service27_Algorithm; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\WdgIf; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\WdgM; ..\..\..\mcal\McuExt_TS_T01D20M1I4R0\include; ..\..\..\mcal\Base_TS_T01D20M1I4R0\include; ..\..\..\mcal\CryIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\Eth_TS_T01D20M1I4R0\include; ..\..\..\service\reentrytest; ..\..\..\service\shell; ..\..\..\driver\include\common; ..\..\..\AUTOSAR_STACK\BSW\BSWConfig\RTE; ..\..\..\CCU_SWC; ..\..\..\CCU_SWC\adc; ..\..\..\CCU_SWC\AppSwcBcm; ..\..\..\CCU_SWC\AppSwcIpm; ..\..\..\CCU_SWC\AppSwcOpm; ..\..\..\CCU_SWC\AppSwcTms; ..\..\..\CCU_SWC\AppSwcVcu; ..\..\..\CCU_SWC\gpio; ..\..\..\CCU_SWC\HBridge; ..\..\..\CCU_SWC\Peps_FML; ..\..\..\CCU_SWC\Pwm; ..\..\..\CCU_SWC\VNQ7E100
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; CFG_XIP; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3420; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; ASSEMBLY; NO_STDLIB
  AARM.AUserIncludes: ..\..\..\arch\armv7-r\; ..\..\..\soc\; ..\..\..\driver; ..\..\..\driver\gic\include; ..\..\..\driver\gic; ..\..\..\driver\gic\common; ..\..\..\driver\gic\lib; ..\..\..\driver\gic\v2; ..\..\..\driver\uart; ..\..\..\driver\uart\sdrv_uart; ..\..\..\service\; ..\..\..\test_suite; ..\..\..\include; ..\..\..\include\common; ..\..\..\include\drivers; ..\..\..\Mcal_Cfg; ..\..\..\Mcal_Cfg\sf\include; ..\..\..\Mcal_Cfg\sf; ..\..\..\Mcal_Cfg\E3_ref_gateway_E3420; ..\..\..\mcal\Lib_TS_T01D20M1I4R0\include; ..\..\..\mcal\Firewall_TS_T01D20M1I4R0\include; ..\..\..\mcal\Base_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mcu_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mcu_TS_T01D20M1I4R0\include\taishan; ..\..\..\mcal\Rte_TS_T01D20M1I4R0\include; ..\..\..\mcal\Det_TS_T01D20M1I4R0\include; ..\..\..\mcal\Gpt_TS_T01D20M1I4R0\include; ..\..\..\mcal\Port_TS_T01D20M1I4R0\include; ..\..\..\mcal\Dio_TS_T01D20M1I4R0\include; ..\..\..\mcal\Dma_TS_T01D20M1I4R0\include; ..\..\..\mcal\CanIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\IOExp\include; ..\..\..\mcal\CanTrcv\include; ..\..\..\mcal\Wdg_TS_T01D20M1I4R0\include; ..\..\..\mcal\Pwm_TS_T01D20M1I4R0\include; ..\..\..\mcal\Icu_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mailbox_TS_T01D20M1I4R0\include; ..\..\..\mcal\Adc_TS_T01D20M1I4R0\include; ..\..\..\mcal\Crypto_TS_T01D20M1I4R0\include; ..\..\..\mcal\Can_TS_T01D20M1I4R0\include; ..\..\..\mcal\Lin_TS_T01D20M1I4R0\include; ..\..\..\mcal\LinIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\Sent_TS_T01D20M1I4R0\include; ..\..\..\mcal\Spi_TS_T01D20M1I4R0\include; ..\..\..\mcal\I2c_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fls_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fee_TS_T01D20M1I4R0\include; ..\..\..\mcal\Eth_TS_T01D20M1I4R0\include; ..\..\..\mcal\EthTrcv_TS_T01D20M1I4R0\include; ..\..\..\mcal\EthIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\RebootService\include; ..\..\..\mcal\IrqM_TS_T01D20M1I4R0\include; ..\..\..\mcal\Xtrg_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fr_TS_T01D20M1I4R0\include; ..\..\..\test_suite\demo\mc\Motor_Lib_TS_T01D20M1I4R0\Inc; ..\..\..\test_suite\demo\mc\Motor_Lib; ..\..\..\test_suite\demo\mc; ..\..\..\driver\lld; ..\..\..\driver\pwm; ..\..\..\driver\btm; ..\..\..\driver\spi; ..\..\..\driver\clk; ..\..\..\driver\i2c; ..\..\..\driver\sbc; ..\..\..\driver\adc; ..\..\..\driver\Epu; ..\..\..\driver\timer; ..\..\..\Mcal_Cfg\E3_ref_gateway_E3420\output\include; ..\..\..\soc\taishan\include; ..\..\..\os\FreeRTOS\Source\include; ..\..\..\os\FreeRTOS\Source\portable\GCC\ARM_CR5; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\OS\kernel; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\OS\arch; ..\..\..\AUTOSAR_STACK\BSW\SystemServices\OS\arch\driver; ..\..\..\AUTOSAR_STACK\BSW\BSWConfig
  OBJCOPY.OOCOutputFile: E3_ref_gateway_E3420_xip.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.elf
  ILINK.IlinkIcfFile: E3_ref_gateway_E3420_xip_Debug_boot.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\tools\sfs\sfs_s26h-hyperflash.img,SFS_BIN,SFS_BIN,8; --keep SFS_BIN; --image_input ..\..\..\tools\IAR_Ddf\flashloader\SemiDrive\3420\bootloader_hyperflash.bin,BTL_BIN,BTL_BIN,8; --keep BTL_BIN
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; CFG_XIP; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3420; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; NO_STDLIB
  ICCARM.CCIncludePath2: ..\..\..\arch\armv7-r\; ..\..\..\soc\; ..\..\..\driver; ..\..\..\driver\gic\include; ..\..\..\driver\gic; ..\..\..\driver\gic\common; ..\..\..\driver\gic\lib; ..\..\..\driver\gic\v2; ..\..\..\driver\uart; ..\..\..\driver\uart\sdrv_uart; ..\..\..\service\; ..\..\..\test_suite; ..\..\..\include; ..\..\..\include\common; ..\..\..\include\drivers; ..\..\..\Mcal_Cfg; ..\..\..\Mcal_Cfg\sf\include; ..\..\..\Mcal_Cfg\sf; ..\..\..\Mcal_Cfg\E3_ref_gateway_E3420; ..\..\..\mcal\Lib_TS_T01D20M1I4R0\include; ..\..\..\mcal\Firewall_TS_T01D20M1I4R0\include; ..\..\..\mcal\Base_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mcu_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mcu_TS_T01D20M1I4R0\include\taishan; ..\..\..\mcal\Rte_TS_T01D20M1I4R0\include; ..\..\..\mcal\Det_TS_T01D20M1I4R0\include; ..\..\..\mcal\Gpt_TS_T01D20M1I4R0\include; ..\..\..\mcal\Port_TS_T01D20M1I4R0\include; ..\..\..\mcal\Dio_TS_T01D20M1I4R0\include; ..\..\..\mcal\Dma_TS_T01D20M1I4R0\include; ..\..\..\mcal\CanIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\IOExp\include; ..\..\..\mcal\CanTrcv\include; ..\..\..\mcal\Wdg_TS_T01D20M1I4R0\include; ..\..\..\mcal\Pwm_TS_T01D20M1I4R0\include; ..\..\..\mcal\Icu_TS_T01D20M1I4R0\include; ..\..\..\mcal\Mailbox_TS_T01D20M1I4R0\include; ..\..\..\mcal\Adc_TS_T01D20M1I4R0\include; ..\..\..\mcal\Crypto_TS_T01D20M1I4R0\include; ..\..\..\mcal\Can_TS_T01D20M1I4R0\include; ..\..\..\mcal\Lin_TS_T01D20M1I4R0\include; ..\..\..\mcal\LinIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\Sent_TS_T01D20M1I4R0\include; ..\..\..\mcal\Spi_TS_T01D20M1I4R0\include; ..\..\..\mcal\I2c_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fls_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fee_TS_T01D20M1I4R0\include; ..\..\..\mcal\Eth_TS_T01D20M1I4R0\include; ..\..\..\mcal\EthTrcv_TS_T01D20M1I4R0\include; ..\..\..\mcal\EthIf_TS_T01D20M1I4R0\include; ..\..\..\mcal\RebootService\include; ..\..\..\mcal\IrqM_TS_T01D20M1I4R0\include; ..\..\..\mcal\Xtrg_TS_T01D20M1I4R0\include; ..\..\..\mcal\Fr_TS_T01D20M1I4R0\include; ..\..\..\test_suite\demo\mc\Motor_Lib_TS_T01D20M1I4R0\Inc; ..\..\..\test_suite\demo\mc\Motor_Lib; ..\..\..\test_suite\demo\mc; ..\..\..\driver\lld; ..\..\..\driver\pwm; ..\..\..\driver\btm; ..\..\..\driver\spi; ..\..\..\driver\clk; ..\..\..\driver\i2c; ..\..\..\driver\sbc; ..\..\..\driver\adc; ..\..\..\driver\Epu; ..\..\..\driver\timer; ..\..\..\Mcal_Cfg\E3_ref_gateway_E3420\output\include; ..\..\..\soc\taishan\include; ..\..\..\os\FreeRTOS\Source\include; ..\..\..\os\FreeRTOS\Source\portable\GCC\ARM_CR5
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __ICCARM__; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; CFG_XIP; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3420; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; ASSEMBLY; NO_STDLIB
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: E3_ref_gateway_E3420_xip_Release.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_withRemap (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REMAP_USED; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; CFG_XIP; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3420; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; NO_STDLIB; DISABLE_MCAL_ASR_VER_CHECK; DISABLE_MCAL_SW_VER_CHECK
  AARM.ADefines: REMAP_USED; __ICCARM__; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; CFG_XIP; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3420; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; ASSEMBLY; NO_STDLIB
  ILINK.IlinkIcfFile: E3_ref_gateway_E3420_xip_Debug_REMAP.icf
  group (top)
    ../../../: main.c
  group arch/armv7-r
    ../../../arch/armv7-r/: arm_atomic.S arm_bits_ops.S arm_irq.c exception.c exception_s.S exceptions.S memclr_opt.S memcpy_opt.S start.S vector.S vPortTaskUsersFPU.h vPortTaskUsesFPU.c
  group AUTOSAR_STACK/ASW/XcpDataTest
    ../../../AUTOSAR_STACK/ASW/XcpDataTest/: XcpData.c XcpData.h Xcprtwtypes.h XcpTest.c XcpTest.h XcpTest_private.h XcpTest_types.h
  group AUTOSAR_STACK/BSWCode/BSWConfig
    ../../../AUTOSAR_STACK/BSW/BSWConfig/: BswM_Cfg.c BswM_Cfg.h BswM_LCfg.c CanIf_Cfg.c CanIf_Cfg.h CanNm_Cfg.c CanNm_Cfg.h CanSM_Cfg.c CanSM_Cfg.h CanTp_Callout.c CanTp_Cfg.h CanTp_PBcfg.c CanTp_PBcfg.h Com_Cfg.c Com_Cfg.h Com_Cfg_Cbk.c Com_Cfg_Cbk.h ComM_Cfg.h ComM_Gent.c ComM_Gent.h ComM_PBCfg.c ComM_PBCfg.h ComStack_Cfg.h Crc_Cfg.h Dcm_Callout.c Dcm_CalloutBoot.h Dcm_Cfg.c Dcm_Cfg.h Dem_Cfg.c Dem_Cfg.h Det_Cfg.c Det_Cfg.h Det_Externals.c Det_Externals.h Ea_Cfg.c Ea_Cfg.h EcuM_Callout_Stubs.c EcuM_Cfg.c EcuM_Cfg.h EcuM_Generated_Types.h EcuM_Lcfg.c EcuM_PbCfg.c Eep_62_Api.c Eep_62_Api.h Eep_62_Cfg.c Eep_62_Cfg.h Eep_Eep_62_Cfg.c Eep_Eep_62_Cfg.h LinIf_Cfg.c LinIf_Cfg.h LinSM_Cfg.c LinSM_Cfg.h MemIf_Cfg.c MemIf_Cfg.h Nm_Cfg.h Nm_Lcfg.c Nm_PBcfg.c NvM_Cfg.c NvM_Cfg.h Os_Cfg.c Os_Cfg.h Os_Cfg_S.h Os_CfgData.h Os_Intvet.c Os_Mp_MemMap.h Os_TestMacros.h Os_UserInf.c PduR_CanIf.h PduR_CanNm.h PduR_CanTp.h PduR_Cfg.c PduR_Cfg.h PduR_Com.h PduR_Dcm.h PduR_LinIf.h PduR_PBcfg.c PduR_PBcfg.h Rte_BswM_Type.h Rte_ComM_Type.h Rte_Dcm.c Rte_Dcm.h Rte_Dcm_Type.h Rte_Dem.c Rte_Dem.h Rte_Dem_Type.h Rte_EcuM_Type.h Rte_NvM_Type.h Rte_WdgM_Type.h WdgIf_Cfg.c WdgIf_Cfg.h WdgM_Cfg.c WdgM_Cfg.h Xcp_Cfg.c Xcp_Cfg.h Xcp_PBcfg.c
  group AUTOSAR_STACK/BSWCode/BSWConfig/RTE
    ../../../AUTOSAR_STACK/BSW/BSWConfig/RTE/: cirq_buffer.c cirq_buffer.h Rte.c Rte.h Rte_AppSwcBcm.c Rte_AppSwcBcm.h Rte_AppSwcBcm_Type.h Rte_AppSwcIpm.c Rte_AppSwcIpm.h Rte_AppSwcIpm_Type.h Rte_AppSwcOpm.c Rte_AppSwcOpm.h Rte_AppSwcOpm_Type.h Rte_AppSwcVcu.c Rte_AppSwcVcu.h Rte_AppSwcVcu_Type.h Rte_Cbk.c Rte_Cbk.h Rte_Data.c Rte_Data.h Rte_DataHandleType.h Rte_Main.h Rte_ME11.c Rte_ME11.h Rte_ME11_Type.h Rte_MemMap.h Rte_Type.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/CanIf
    ../../../AUTOSAR_STACK/BSW/Communication/CAN/CanIf/: CanIf.c CanIf.h CanIf_Cbk.h CanIf_DiagRoute.c CanIf_DiagRoute.h CanIf_MemMap.h CanIf_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/CanNm
    ../../../AUTOSAR_STACK/BSW/Communication/CAN/CanNm/: CanNm.c CanNm.h CanNm_Cbk.h CanNm_Internal.h CanNm_MemMap.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/CanSM
    ../../../AUTOSAR_STACK/BSW/Communication/CAN/CanSM/: CanSM.c CanSM.h CanSM_BswM.h CanSM_Cbk.h CanSM_MemMap.h CanSM_TxTimeoutException.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/CanTp
    ../../../AUTOSAR_STACK/BSW/Communication/CAN/CanTp/: CanTp.c CanTp.h CanTp_Cbk.h CanTp_Internal.c CanTp_Internal.h CanTp_MemMap.h CanTp_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Com
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Com/: Com.c Com.h Com_Cbk.h Com_GwInternal.c Com_Internal.c Com_Internal.h Com_MemMap.h Com_RxInternal.c Com_TxInternal.c Com_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Dcm
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Dcm/: Dcm.c Dcm.h Dcm_Cbk.h Dcm_Internal.h Dcm_MemMap.h Dcm_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Dcm/DcmDsd
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Dcm/DcmDsd/: DcmDsd.c DcmDsd.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Dcm/DcmDsl
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Dcm/DcmDsl/: DcmDsl.h DcmDsl_CommManage.c DcmDsl_CommManage.h DcmDsl_MsgManage.c DcmDsl_MsgManage.h DcmDsl_PendingManage.c DcmDsl_PendingManage.h DcmDsl_ProtocolManage.c DcmDsl_ProtocolManage.h DcmDsl_SecurityManage.c DcmDsl_SecurityManage.h DcmDsl_SessionManage.c DcmDsl_SessionManage.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Dcm/DcmDsp
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Dcm/DcmDsp/: DcmDsp.c DcmDsp.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Dcm/DcmDsp/UDS
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Dcm/DcmDsp/UDS/: Dcm_UDS0x10.c Dcm_UDS0x11.c Dcm_UDS0x14.c Dcm_UDS0x19.c Dcm_UDS0x22.c Dcm_UDS0x23.c Dcm_UDS0x24.c Dcm_UDS0x27.c Dcm_UDS0x28.c Dcm_UDS0x2A.c Dcm_UDS0x2C.c Dcm_UDS0x2E.c Dcm_UDS0x2F.c Dcm_UDS0x31.c Dcm_UDS0x34.c Dcm_UDS0x35.c Dcm_UDS0x36.c Dcm_UDS0x37.c Dcm_UDS0x38.c Dcm_UDS0x3D.c Dcm_UDS0x3E.c Dcm_UDS0x85.c Dcm_UDS0x86.c UDS.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Dcm/Service27_Algorithm
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Dcm/Service27_Algorithm/: Service27_Algorithm.c Service27_Algorithm.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/NmIf
    ../../../AUTOSAR_STACK/BSW/Communication/Common/NmIf/: Nm.c Nm.h Nm_Cbk.h Nm_Internal.h Nm_MemMap.h NmStack_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/PDUR
    ../../../AUTOSAR_STACK/BSW/Communication/Common/PDUR/: PduR.c PduR.h PduR_Internal.c PduR_Internal.h PduR_MemMap.h PduR_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/Common/Xcp
    ../../../AUTOSAR_STACK/BSW/Communication/Common/Xcp/: Xcp.c Xcp.h Xcp_Cal.c Xcp_Daq.c Xcp_GenericTypes.h Xcp_Interface.c Xcp_Interface.h Xcp_Internal.h Xcp_MemMap.h Xcp_Pgm.c Xcp_Ram.c Xcp_Std.c XcpOnCan.c XcpOnCan_Cbk.h XcpOnEth.c XcpOnEth_Cbk.h
  group AUTOSAR_STACK/BSWCode/Communication/LIN/LinIf
    ../../../AUTOSAR_STACK/BSW/Communication/LIN/LinIf/: LinIf.c LinIf.h LinIf_Cbk.h LinIf_Internal.h LinIf_Master.c LinIf_Master.h LinIf_MemMap.h LinIf_Types.h LinTp.c LinTp.h LinTp_Internal.c LinTp_Internal.h LinTp_Master.c LinTp_Master.h LinTp_Types.h
  group AUTOSAR_STACK/BSWCode/Communication/LIN/LinSM
    ../../../AUTOSAR_STACK/BSW/Communication/LIN/LinSM/: LinSM.c LinSM.h LinSM_Cbk.h LinSM_MemMap.h
  group AUTOSAR_STACK/BSWCode/Libraries/Crc
    ../../../AUTOSAR_STACK/BSW/Libraries/Crc/: Crc.c Crc.h Crc_MemMap.h
  group AUTOSAR_STACK/BSWCode/Libraries/FreeRTimer
    ../../../AUTOSAR_STACK/BSW/Libraries/FreeRTimer/: FreeRTimer.c FreeRTimer.h
  group AUTOSAR_STACK/BSWCode/Memory/Ea
    ../../../AUTOSAR_STACK/BSW/Memory/Ea/: Ea.c Ea.h Ea_MemMap.h Ea_Types.h
  group AUTOSAR_STACK/BSWCode/Memory/Eep
    ../../../AUTOSAR_STACK/BSW/Memory/Eep/: Eep.h Eep_62.c Eep_62.h Eep_62_Cbk.c Eep_62_Cbk.h Eep_62_MemMap.h Eep_62_Types.h EepCAV24C64.c EepCAV24C64.h SchM_62_Eep.h
  group AUTOSAR_STACK/BSWCode/Memory/MemIf
    ../../../AUTOSAR_STACK/BSW/Memory/MemIf/: MemIf.c MemIf.h MemIf_MemMap.h MemIf_Types.h
  group AUTOSAR_STACK/BSWCode/Memory/NvM
    ../../../AUTOSAR_STACK/BSW/Memory/NvM/: NvM.c NvM.h NvM_Cbk.h NvM_Inter.c NvM_Inter.h NvM_MemMap.h NvM_Types.h
  group AUTOSAR_STACK/BSWCode/SystemServices/BswM
    ../../../AUTOSAR_STACK/BSW/SystemServices/BswM/: BswM.c BswM.h BswM_AvbAction.c BswM_Bsw.c BswM_Bsw.h BswM_CanSM.c BswM_CanSM.h BswM_Check_Action.c BswM_Check_Action.h BswM_ComM.c BswM_ComM.h BswM_Dcm.c BswM_Dcm.h BswM_DetCheck.c BswM_EcuM.c BswM_EcuM.h BswM_EthIf.c BswM_EthIf.h BswM_EthSM.c BswM_EthSM.h BswM_FrSM.c BswM_FrSM.h BswM_Internal.h BswM_J1939Dcm.c BswM_J1939Dcm.h BswM_J1939Nm.c BswM_J1939Nm.h BswM_LinSM.c BswM_LinSM.h BswM_LinTp.c BswM_LinTp.h BswM_MemMap.h BswM_Nm.c BswM_Nm.h BswM_NvM.c BswM_NvM.h BswM_Sd.c BswM_Sd.h BswM_Swc.c BswM_Swc.h BswM_TimerControl.c BswM_Types.h BswM_WdgM.c BswM_WdgM.h
  group AUTOSAR_STACK/BSWCode/SystemServices/ComM
    ../../../AUTOSAR_STACK/BSW/SystemServices/ComM/: ComM.c ComM.h ComM_BswM.h ComM_BusSM.h ComM_Ch.c ComM_Ch.h ComM_Dcm.h ComM_EcuM.h ComM_Internal.h ComM_MemMap.h ComM_Nm.h ComM_Pnc.c ComM_Pnc.h ComM_Types.h ComM_Version.h
  group AUTOSAR_STACK/BSWCode/SystemServices/Dem
    ../../../AUTOSAR_STACK/BSW/SystemServices/Dem/: Dem.c Dem.h Dem_CfgEnum.h Dem_CfgTypes.h Dem_Dcm.c Dem_Dcm.h Dem_EventDebounce.c Dem_EventMemory.c Dem_EventQueue.c Dem_ExtendedData.c Dem_FreezeFrame.c Dem_Internal.c Dem_Internal.h Dem_MemMap.h Dem_Types.h
  group AUTOSAR_STACK/BSWCode/SystemServices/Det
    ../../../AUTOSAR_STACK/BSW/SystemServices/Det/: Det.c Det.h Det_MemMap.h Det_Types.h
  group AUTOSAR_STACK/BSWCode/SystemServices/EcuM
    ../../../AUTOSAR_STACK/BSW/SystemServices/EcuM/: EcuM.c EcuM.h EcuM_AlarmClock.c EcuM_Cbk.h EcuM_Externals.h EcuM_Internal.h EcuM_MemMap.h EcuM_Shutdown.c EcuM_Sleep.c EcuM_StartUp.c EcuM_Types.h EcuM_Up.c
  group AUTOSAR_STACK/BSWCode/SystemServices/OS/arch
    ../../../AUTOSAR_STACK/BSW/SystemServices/OS/arch/: e3430_mpu_s.S e3430_vic.c e3430_vic.h Os_ContexSwap_S.S Os_Extend.c Os_Extend.h Os_irq.c Os_IsrHandler_S.S Os_Processor.c Os_Processor.h Os_SysAsmFun.h Os_SysAsmFun.s Os_Timer.c Os_Timer.h Os_Trap.c
  group AUTOSAR_STACK/BSWCode/SystemServices/OS/arch/driver
    ../../../AUTOSAR_STACK/BSW/SystemServices/OS/arch/driver/: sdrv_btm_v2.c sdrv_btm_v2.h
  group AUTOSAR_STACK/BSWCode/SystemServices/OS/kernel
    ../../../AUTOSAR_STACK/BSW/SystemServices/OS/kernel/: Os.h Os_Alarm.c Os_Appl.c Os_Core.c Os_Counter.c Os_Err.h Os_Event.c Os_Hook.c Os_Internal.h Os_Interrupt.c Os_Ioc.c Os_Kernel.c Os_Marcos.h Os_MemMap.h Os_Mprot.c Os_Resource.c Os_ScheduleTable.c Os_Spinlock.c Os_Sprot.c Os_Task.c Os_Tprot.c Os_Types.h
  group AUTOSAR_STACK/BSWCode/SystemServices/WdgIf
    ../../../AUTOSAR_STACK/BSW/SystemServices/WdgIf/: WdgExt.c WdgExt.h WdgIf.c WdgIf.h WdgIf_MemMap.h WdgIf_Types.h
  group AUTOSAR_STACK/BSWCode/SystemServices/WdgM
    ../../../AUTOSAR_STACK/BSW/SystemServices/WdgM/: WdgM.c WdgM.h WdgM_CfgType.h WdgM_MemMap.h WdgM_Type.h
  group AUTOSAR_STACK/RTE/StaticCode/Rte_SchM
    ../../../AUTOSAR_STACK/RTE/StaticCode/Rte_SchM/: Rte_SchM.c Rte_SchM.h
  group AUTOSAR_STACK/RTE/StaticCode/SchM
    ../../../AUTOSAR_STACK/RTE/StaticCode/SchM/: SchM_BswM.h SchM_Dcm.h SchM_EcuM.h
  group CCU_SWC
    ../../../CCU_SWC/: DIAG_ABI.c DIAG_ABI.h ME11_ABI.c ME11_ABI.h PEPS_ABI.c PEPS_ABI.h rtwtypes.h
  group CCU_SWC/adc
    ../../../CCU_SWC/adc/: Adc_rte.c Adc_rte.h
  group CCU_SWC/AppSwcBcm
    ../../../CCU_SWC/AppSwcBcm/: AppSwcBcm.c AppSwcBcm.h AppSwcBcm_MemMap.h AppSwcBcm_types.h calPrmsBcm.c calPrmsBcm.h encipher.c encipher.h monPrmsBcm.c monPrmsBcm.h rtwtypes.h
  group CCU_SWC/AppSwcIpm
    ../../../CCU_SWC/AppSwcIpm/: AppSwcIpm.c AppSwcIpm.h AppSwcIpm_MemMap.h AppSwcIpm_types.h calPrmsIpm.c calPrmsIpm.h monPrmsIpm.c monPrmsIpm.h
  group CCU_SWC/AppSwcOpm
    ../../../CCU_SWC/AppSwcOpm/: AppSwcOpm.c AppSwcOpm.h AppSwcOpm_MemMap.h AppSwcOpm_types.h calPrmsOpm.c calPrmsOpm.h monPrmsOpm.c monPrmsOpm.h
  group CCU_SWC/AppSwcTms
    ../../../CCU_SWC/AppSwcTms/: ME11.c ME11.h ME11_MemMap.h ME11_types.h TMS_CalibrationData.c TMS_CalibrationData.h TMS_MonitorData.c TMS_MonitorData.h zero_crossing_types.h
  group CCU_SWC/AppSwcVcu
    ../../../CCU_SWC/AppSwcVcu/: AppSwcVcu.c AppSwcVcu.h AppSwcVcu_MemMap.h AppSwcVcu_types.h calPrmsVcu.c calPrmsVcu.h monPrmsVcu.c monPrmsVcu.h
  group CCU_SWC/gpio
    ../../../CCU_SWC/gpio/: Gpio_rte.c Gpio_rte.h
  group CCU_SWC/HBridge
    ../../../CCU_SWC/HBridge/: HBridge_rte.c HBridge_rte.h
  group CCU_SWC/Peps_FML
    ../../../CCU_SWC/Peps_FML/: Aes.c Aes.h Aes_cf.h Fobs_Tracking_Algorithm.C Fobs_Tracking_Algorithm.H Immo_AES128SWEnc.c Immo_AES128SWEnc.h Immo_Aes_Fml.C Immo_Aes_Fml.h Joker.c Joker.h LoopFifo.c LoopFifo.h Nck2910.c Nck2910.h NxpMath.c NxpMath.h Pke_Pks_App.c Pke_Pks_APP.h Platform_cfg.c platform_cfg.h Qn_Platform_Types.h Uhf_Fml.c Uhf_Fml.h
  group CCU_SWC/Pwm
    ../../../CCU_SWC/Pwm/: Pwm_rte.c Pwm_rte.h
  group CCU_SWC/VNQ7E100
    ../../../CCU_SWC/VNQ7E100/: VNQ7E100.c VNQ7E100.h
  group Cdd
    ../../../Cdd/: AD_CD4067.c AD_CD4067.h
  group driver/Audio
    ../../../driver/Audio/: ADAU1462.c ADAU1462_API.h ADAU1462_Cfg.h
  group driver/btm
    ../../../driver/btm/: sdrv_btm.c sdrv_btm.h sdrv_btm_common.h
  group driver/HBridge
    ../../../driver/HBridge/: DR702.c DR702.h MPQ6612A.c MPQ6612A.h VNH5200.c VNH5200.h
  group driver/HighSide
    ../../../driver/HighSide/: TLE75004.c TLE75004_Api.h TLE75004_Cfg.h TLE75242.c TLE75242_Api.h TLE75242_Cfg.h TLE8108EM.c TLE8108EM.h
  group driver/HSSwitch
    ../../../driver/HSSwitch/: BTS7012.c BTS7012.h BTS7020.c BTS7020.h BTS7120.c BTS7120.h
  group driver/ioexp
    ../../../driver/ioexp/: IoExp_TCA6408.c IoExp_TCA6408_Api.h IoExp_TCA6408_Cfg.h IoExp_TCA6424A.c IoExp_TCA6424A_Api.h IoExp_TCA6424A_Cfg.h IoExp_TCA9539.c IoExp_TCA9539_Api.h IoExp_TCA9539_Cfg.h
  group driver/lld
    ../../../driver/lld/: e3_adc_lld.h sdrv_btm_hw.c sdrv_btm_hw.h sdrv_etimer_lld.c sdrv_etimer_lld.h sdrv_pwm_lld.c sdrv_pwm_lld.h
  group driver/RF
    ../../../driver/RF/: NCK2910_Api.c NCK2910_Api.h NJJ29C0B_Api.c NJJ29C0B_API.h
  group driver/sbc
    ../../../driver/sbc/: TLE94x1.c TLE94x1_SPI.c
  group driver/TLE94103
    ../../../driver/TLE94103/: TLE94103.c TLE94103.h
  group driver/uart
    ../../../driver/uart/d_ip_uart/: d_ip_uart.c uart_reg.h
    ../../../driver/uart/: uart.c uart.h
  group mcal/Adc_TS_T01D20M1I4R0/src
    ../../../mcal/Adc_TS_T01D20M1I4R0/src/: Adc.c Adc_Hw_E3.c Adc_irq.c
  group mcal/base/src
    ../../../mcal/Base_TS_T01D20M1I4R0/src/: FuSaMcalReportError.c
  group mcal/Can_TS_T01D20M1I4R0/src
    ../../../mcal/Can_TS_T01D20M1I4R0/src/: Can.c Can_IP.c Can_Irq.c
  group mcal/cryif/src
    ../../../mcal/CryIf_TS_T01D20M1I4R0/src/: CryIf.c
  group mcal/Crypto_TS_T01D20M1I4R0/src
    ../../../mcal/Crypto_TS_T01D20M1I4R0/src/: Crypto.c Crypto_DerParser.c Crypto_Hsm.c Crypto_Ip.c Crypto_KeyManagement.c Crypto_RSAPadding.c Crypto_ShareMem.c
  group mcal/Dio_TS_T01D20M1I4R0/src
    ../../../mcal/Dio_TS_T01D20M1I4R0/src/: Dio.c Dio_Ip.c
  group mcal/Dma_TS_T01D20M1I4R0/src
    ../../../mcal/Dma_TS_T01D20M1I4R0/src/: Dma.c Dma_ASM.S Dma_Ip.c Dma_Irq.c
  group mcal/Fee_TS_T01D20M1I4R0/src
    ../../../mcal/Fee_TS_T01D20M1I4R0/src/: Fee.c fee_ops.c
  group mcal/Firewall_TS_T01D20M1I4R0/src
    ../../../mcal/Firewall_TS_T01D20M1I4R0/src/: Firewall.c Firewall_Dio.c Firewall_Mac.c Firewall_Mpc.c Firewall_Ppc.c
  group mcal/Fls_TS_T01D20M1I4R0/src
    ../../../mcal/Fls_TS_T01D20M1I4R0/src/: Fls.c Fls_Asm.S Fls_Hyperbus.c Fls_Ip.c Fls_IpDrv.c Fls_Spibus.c
  group mcal/Gpt_TS_T01D20M1I4R0/src
    ../../../mcal/Gpt_TS_T01D20M1I4R0/src/: Gpt.c Gpt_Ip.c Gpt_Irq.c
  group mcal/I2c_TS_T01D20M1I4R0/src
    ../../../mcal/I2c_TS_T01D20M1I4R0/src/: I2c.c I2c_Irq.c Sdrv_I2c.c Sdrv_I2c_drv.c
  group mcal/Icu_TS_T01D20M1I4R0/src
    ../../../mcal/Icu_TS_T01D20M1I4R0/src/: Icu.c Icu_Ip.c Icu_Irq.c
  group mcal/IrqM_TS_T01D20M1I4R0/src
    ../../../mcal/IrqM_TS_T01D20M1I4R0/src/: irq.c irq_wrapper.c sdrv_vic.c sdrv_vic_s.S
  group mcal/Lib_TS_T01D20M1I4R0/src
    ../../../mcal/Lib_TS_T01D20M1I4R0/src/: crc16.c crc32.c crc4.c libc_call.c mem_libc.c ring.c send_char.c str_libc.c
  group mcal/Lin_TS_T01D20M1I4R0/src
    ../../../mcal/Lin_TS_T01D20M1I4R0/src/: Lin.c Lin_Hw.c Lin_Icu_Abr_E3.c Lin_Ioc_E3.c Lin_Irq.c Lin_Uart_E3.c
  group mcal/Mailbox_TS_T01D20M1I4R0/src
    ../../../mcal/Mailbox_TS_T01D20M1I4R0/src/: mbox.c mbox_core.c sdrv_e3_mbox_drv.c sdrv_mbox.c
  group mcal/Mcu_TS_T01D20M1I4R0/src
    ../../../mcal/McuExt_TS_T01D20M1I4R0/include/: arch.h Ckgen_Reg.h Iramc_Reg.h Mcu_Iramc.h Mcu_LpSmc.h Mcu_Mpu.h Mcu_Scr.h Mcu_ScrBits.h Mcu_Smc.h Mcu_UserCallouts.h Scr_Reg.h Smc_Reg.h soc.h
    ../../../mcal/Mcu_TS_T01D20M1I4R0/src/: Mcu.c Mcu_AnalogTrim.c Mcu_Ckgen.c Mcu_CkgenDrv.c Mcu_Clk.c Mcu_DcdcLdo.c Mcu_Delay.c Mcu_DelayAsm.S Mcu_Extend.c Mcu_KickCore.c Mcu_Modules.c Mcu_Pll.c Mcu_PllDrv.c Mcu_Pmu.c Mcu_PvtSens.c Mcu_Reset.c Mcu_ResetDrv.c Mcu_Rstgen.c Mcu_Rtc.c Mcu_RtcMode.c Mcu_Soc.c Mcu_Vd.c Mcu_Xtal.c
  group mcal/McuExt_TS_T01D20M1I4R0/src
    ../../../mcal/McuExt_TS_T01D20M1I4R0/src/: Mcu_Arch.S Mcu_Cache.S Mcu_Iramc.c Mcu_LpSmc.c Mcu_Mpu.c Mcu_Scr.c Mcu_Smc.c Mcu_UserCallouts.c
  group mcal/Port_TS_T01D20M1I4R0/src
    ../../../mcal/Port_TS_T01D20M1I4R0/src/: Port.c Port_Ip.c
  group mcal/Pwm_TS_T01D20M1I4R0/src
    ../../../mcal/Pwm_TS_T01D20M1I4R0/src/: Pwm.c Pwm_Ip.c Pwm_Irq.c
  group mcal/Rte_TS_T01D20M1I4R0/src
    ../../../mcal/Rte_TS_T01D20M1I4R0/src/: SchM_Base.c
  group mcal/Sent_TS_T01D20M1I4R0/src
    ../../../mcal/Sent_TS_T01D20M1I4R0/src/: Sent.c Sent_Ip_E3.c Sent_Irq_E3.c
  group mcal/Spi_TS_T01D20M1I4R0/src
    ../../../mcal/Spi_TS_T01D20M1I4R0/src/: Spi.c Spi_Driver.c Spi_Ip.c Spi_Irq.c Spi_Mld.c
  group mcal/Wdg_TS_T01D20M1I4R0/src
    ../../../mcal/Wdg_TS_T01D20M1I4R0/src/: Wdg.c Wdg_140_Instance1_Wdt.c Wdg_140_Instance2_Wdt.c Wdg_140_Instance3_Wdt.c Wdg_140_Instance4_Wdt.c Wdg_140_Instance5_Wdt.c Wdg_140_Instance6_Wdt.c Wdg_140_Instance8_Wdt.c Wdg_Ip.c Wdg_Irq.c
  group mcal/Xtrg_TS_T01D20M1I4R0/src
    ../../../mcal/Xtrg_TS_T01D20M1I4R0/src/: Xtrg.c Xtrg_Ip.c
  group Mcal_Cfg/E3_ref_gateway_E3420
    ../../../Mcal_Cfg/E3_ref_gateway_E3420/: board.c
  group Mcal_Cfg/E3_ref_gateway_E3420/output/src
    ../../../Mcal_Cfg/E3_ref_gateway_E3420/output/src/: Adc_PbCfg.c Can_PBCfg.c Crypto_PBCfg.c Dio_Cfg.c Dma_PBCfg.c Eth_PBCfg.c EthTrcv_PBCfg.c Fee_Cfg.c Firewall_Cfg.c Firewall_Dio_Cfg.c Firewall_Mac_Cfg.c Firewall_Mpc_Cfg.c Firewall_Ppc_Cfg.c Fls_Cfg.c Gpt_PBCfg.c I2c_Cfg.c Icu_PBCfg.c IrqM_PBCfg.c Lin_PBCfg.c Mcu_Cfg.c Mcu_ClkCfg.c Mcu_RstCfg.c Port_Cfg.c Port_Hw_E3_IS.c Pwm_Cfg.c Sent_PBCfg.c Spi_PbCfg.c Wdg_140_Instance1_PBCfg.c Wdg_140_Instance2_PBCfg.c Wdg_140_Instance3_PBCfg.c Wdg_140_Instance4_PBCfg.c Wdg_140_Instance5_PBCfg.c Wdg_140_Instance6_PBCfg.c Wdg_140_Instance8_PBCfg.c Wdg_PBCfg.c Xtrg_PBCfg.c
  group service/reentry_test
    ../../../service/reentrytest/: reentry_test.c
  group service/shell
    ../../../service/shell/: mini_printf.c shell.c
