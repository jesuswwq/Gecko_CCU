<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\E3_ref_gateway_E3420_xip.ewp</path>
    </project>
    <batchBuild />
</workspace>
