# IAR project BiHu_E3420_FBL_IAR_8_50_6_Project.ewp, settings and files
configuration debugram (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 44
  General.FPU2: 3
  ICCARM.CCDefines: PROJECT_SPECIAL_BIHU; PROJECT_SPECIAL; DEBUGRAM; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; __ICCARM__; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=0x1F8000; CFG_MBOX_SIZE=0x8000; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3430; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; NO_STDLIB; MCU_CKGEN_RESERVED_FUNCs
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: ..\fbl\Board\armv7-r; ..\fbl\Board\include; ..\src\01_ProductCode\Appl; ..\src\01_ProductCode\CanIf; ..\src\01_ProductCode\CanTp; ..\src\01_ProductCode\Can_Trcv; ..\src\01_ProductCode\Dcm; ..\src\01_ProductCode\DP; ..\src\01_ProductCode\Fl; ..\src\01_ProductCode\FlashIf; ..\src\01_ProductCode\GptIf; ..\src\01_ProductCode\SecM; ..\src\01_ProductCode\SecM\Algorithm\AES_CMAC; ..\src\01_ProductCode\SecM\Algorithm\AES_CMAC\AES; ..\src\01_ProductCode\SecM\Algorithm\Crc; ..\src\01_ProductCode\SecM\Algorithm\HASH256; ..\src\01_ProductCode\SecM\Algorithm\Lzss; ..\src\01_ProductCode\WdgIf; ..\src\02_Config; ..\src\mcal\Base_TS_T01D20M1I4R0\include; ..\src\mcal\CanIf_TS_T01D20M1I4R0\include; ..\src\mcal\Can_TS_T01D20M1I4R0\include; ..\src\mcal\config\include; ..\src\mcal\Dio_TS_T01D20M1I4R0\include; ..\src\mcal\Dma_TS_T01D20M1I4R0\include; ..\src\mcal\Fee_TS_T01D20M1I4R0\include; ..\src\mcal\Fls_TS_T01D20M1I4R0\include; ..\src\mcal\Gpt_TS_T01D20M1I4R0\include; ..\src\mcal\I2c_TS_T01D20M1I4R0\include; ..\src\mcal\IrqM_TS_T01D20M1I4R0\include; ..\src\mcal\Lib_TS_T01D20M1I4R0\include; ..\src\mcal\Mailbox_TS_T01D20M1I4R0\include; ..\src\mcal\Mcu_TS_T01D20M1I4R0\include; ..\src\mcal\Port_TS_T01D20M1I4R0\include; ..\src\mcal\Rte_TS_T01D20M1I4R0\include; ..\src\mcal\Spi_TS_T01D20M1I4R0\include; ..\src\mcal\Wdg_TS_T01D20M1I4R0\include; ..\src\Rte; ..\src\Rte\Det; ..\src\Rte\ioexp; ..\src\Rte\NvMem; ..\src\Rte\sdkfile
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3430; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; ASSEMBLY; NO_STDLIB; MCU_CKGEN_RESERVED_FUNCs
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BiHu_E3420_FBL_IAR_8_50_6_Project_bl.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.elf
  ILINK.IlinkIcfFile: LinkFile\BiHu_E3420_FBL_IAR_8_50_6_Project_hyperflash.icf
  ILINK.IlinkExtraOptions: --image_input tools\sfs\sfs_s26h-hyperflash.img,SFS_BIN,SFS_BIN,8; --keep SFS_BIN
  ILINK.IlinkProgramEntryLabel: _start
configuration debugramfls (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: E3430_SF SemiDrive E3430_SF
  ICCARM.CCDefines: PROJECT_FLS; DEBUGRAM; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; __ICCARM__; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=0x1F8000; CFG_MBOX_SIZE=0x8000; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3430; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; NO_STDLIB; MCU_CKGEN_RESERVED_FUNCs
  OBJCOPY.OOCOutputFile: BiHu_E3420_FBL_IAR_8_50_6_Project.hex
  postbuild: tools\atb_signer_win\atb_signer.exe sign --v 2 --sec_ver 0x1234 --dgst sha256 --iib core=0 type=0x0 image=debugram\Exe\$PROJ_FNAME$.bin to=0x404000 entry=0x404000 --of debugram\$PROJ_FNAME$.elf.bin.pac
  ILINK.IlinkIcfFile: LinkFile\BiHu_E3420_FBL_IAR_8_50_6_Project_fls_hyperflash.icf
  ILINK.IlinkExtraOptions: --image_input tools\sfs\sfs_is25-1-1-4.img,SFS_BIN,SFS_BIN,8; --keep SFS_BIN
configuration debugapp (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: E3430_SF SemiDrive E3430_SF
  ICCARM.CCDefines: PROJECT_SPECIAL; PROJECT_APP; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; __ICCARM__; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=0x1F8000; CFG_MBOX_SIZE=0x8000; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3430; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; NO_STDLIB; MCU_CKGEN_RESERVED_FUNCs
  AARM.ADefines: PROJECT_APP; __ICCARM__; __ARM_ARCH=7; CONFIG_CR5_SF; CFG_DRV_UART; TTY_UART=UART7; EN_UNIFIED_IMAGE; CFG_ARCH_CR5_AHB_EN; MCU_IP_UART4_USED=STD_ON; MCU_CFG_DO_VECTOR_TBL_REMAP; CFG_SRV_SHELL; SEMIDRIVE_E3_SERIES; MOTOR_SRC_USE; CFG_ARCH_TCM; CFG_SOC_RAM_ECC; CFG_ARCH_FPU; MEMCPY_ASM_OPTIMIZED; MEMCLR_ASM_OPTIMIZED; CFG_FAST_FIFO_WR32; CFG_ARCH_R7_MPU_BG_EN; CFG_ARCH_LLPP_EN; CFG_MCU_ASM_DWORD_STD; CFG_RAMSEC_INIT_CHK_TCM; CFG_INTERRUPT_ENABLE; NO_STD_PRINTF; CFG_DMA_SUPPORT_STATIC_ALLOCATION; CFG_CPU_TYPE=CPU_TYPE_32; MCU_CFG_SET_MODE; CFG_MBOX_BASE=; CFG_MBOX_SIZE=; ARCH_armv7_r; CPU_cortex_r5; SOC_taishan; CORE_sf; TC_; BOARD_E3_ref_gateway_E3430; AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; VCAN; DEBUG_LEVEL=1; ASSEMBLY; NO_STDLIB; MCU_CKGEN_RESERVED_FUNCs
  OBJCOPY.OOCOutputFile: BiHu_E3420_FBL_IAR_8_50_6_Project.hex
  ILINK.IlinkIcfFile: LinkFile\BiHu_E3420_FBL_IAR_8_50_6_Project_xip_hyperflash_AB.icf
  ILINK.IlinkExtraOptions: --image_input tools\sfs\sfs_s26h-hyperflash.img,SFS_BIN,SFS_BIN,8; --keep SFS_BIN; --image_input tools\3420\bootloader_hyperflash.bin,BTL_BIN,BTL_BIN,8; --keep BTL_BIN
  group (top)
    ./: main.c
    ../src/Rte/: Rte_Step_Check.c
  group Board/armv7-r
    Board/armv7-r/: arm_atomic.S arm_bits_ops.S arm_irq.c exception.c exception_s.S exceptions.S memclr_opt.S memcpy_opt.S start.S vector.S
  group Board/src
    Board/src/: board.c Mcu_Modules.c Mcu_Soc.c
  group src
    ../src/01_ProductCode/SecM/Algorithm/AES_CMAC/AES/: Aes128.c
    ../src/01_ProductCode/Appl/: Appl.c Appl_Dcm.c
    ../src/02_Config/: Appl_Callout.c Appl_Cfg.c CanIf_Cfg.c CanTp_Cfg.c Dcm_Cfg.c FL_Cfg.c PduR_Callout.c Rte_Dcm.c Rte_FL.c SecM_Cfg.c
    ../src/01_ProductCode/SecM/Algorithm/Crc/: Cal.c
    ../src/mcal/Can_TS_T01D20M1I4R0/src/: Can.c Can_IP.c Can_Irq.c
    ../src/mcal/config/src/: Can_PBCfg.c Dio_Cfg.c Dma_PBCfg.c Fee_Cfg.c Fls_Cfg.c Gpt_PBCfg.c I2c_Cfg.c IrqM_PBCfg.c Mcu_Cfg.c Mcu_ClkCfg.c Mcu_RstCfg.c Port_Cfg.c Port_Hw_E3_IS.c Spi_PbCfg.c Wdg_140_Instance1_PBCfg.c Wdg_140_Instance2_PBCfg.c Wdg_140_Instance3_PBCfg.c Wdg_140_Instance4_PBCfg.c Wdg_140_Instance5_PBCfg.c Wdg_140_Instance6_PBCfg.c Wdg_140_Instance8_PBCfg.c Wdg_PBCfg.c
    ../src/01_ProductCode/Can_Trcv/: Can_Trcv.c
    ../src/01_ProductCode/CanIf/: CanIf.c
    ../src/01_ProductCode/CanTp/: CanTp.c
    ../src/01_ProductCode/SecM/Algorithm/AES_CMAC/: Cmac.c
    ../src/mcal/Lib_TS_T01D20M1I4R0/src/: crc32.c crc4.c libc_call.c mem_libc.c ring.c send_char.c str_libc.c
    ../src/01_ProductCode/Dcm/: Dcm.c Dcm_Dsp.c
    ../src/Rte/Det/: Det_Api.c
    ../src/mcal/Dio_TS_T01D20M1I4R0/src/: Dio.c Dio_IP.c Dio_UserCallouts.c
    ../src/mcal/Dma_TS_T01D20M1I4R0/src/: Dma_Drv.c Dma_Drv_Cfg.c Dma_Helper.c sdrv_dma.c sdrv_dmac.c
    ../src/01_ProductCode/DP/: DP.c
    ../src/mcal/Mcu_TS_T01D20M1I4R0/src/: e3_ckgen.c e3_ckgen_drv.c e3_clk.c e3_kick_core.c e3_pll.c e3_pll_drv.c Mcu.c Mcu_Arch.S Mcu_Cache.S Mcu_Ckgen.c Mcu_Dcdc_Ldo.c Mcu_Delay.c Mcu_Delay_asm.S Mcu_Iramc.c Mcu_Mpu.c Mcu_Pmu.c Mcu_PvtSens.c Mcu_RegBase.c Mcu_Reset.c Mcu_Rtc.c Mcu_Scr.c Mcu_Smc.c Mcu_UserCallouts.c Mcu_Xtal.c taishan_reset_drv.c taishan_rstgen.c
    ../src/mcal/Spi_TS_T01D20M1I4R0/src/: e3_ip_spi.c mld_spi.c Spi.c Spi_Driver.c Spi_Irq.c
    ../src/mcal/Fee_TS_T01D20M1I4R0/src/: Fee.c fee_ops.c
    ../src/01_ProductCode/Fl/: FL.c
    ../src/01_ProductCode/FlashIf/: FLashIf.c
    ../src/mcal/Fls_TS_T01D20M1I4R0/src/: Fls.c hyperbus.c spi_nor.c taishan_xspi.c taishan_xspi_drv.c
    ../src/mcal/Gpt_TS_T01D20M1I4R0/src/: Gpt.c Gpt_Ip_E3.c Gpt_Irq_E3.c
    ../src/01_ProductCode/GptIf/: GptIf.c
    ../src/mcal/I2c_TS_T01D20M1I4R0/src/: I2c.c I2c_Irq.c Sdrv_I2c.c Sdrv_I2c_drv.c
    ../src/Rte/ioexp/: IoExp_TCA6424A.c
    ../src/mcal/IrqM_TS_T01D20M1I4R0/src/: irq.c irq_wrapper.c sdrv_vic.c sdrv_vic_s.S
    ../src/01_ProductCode/SecM/Algorithm/Lzss/: lzss_decomp.c
    ../src/mcal/Mailbox_TS_T01D20M1I4R0/src/: mbox.c mbox_core.c sdrv_e3_mbox_drv.c sdrv_mbox.c
    ../src/Rte/NvMem/: NvMem.c
    ../src/mcal/Port_TS_T01D20M1I4R0/src/: Port.c Port_Hw_E3.c Port_Hw_E3_Pinctrl.c
    ../src/Rte/sdkfile/: remap.c
    ../src/Rte/: Rte_ABSwap.c Rte_Address.c Rte_Alg_Bihu.c Rte_Algorithms.c Rte_App.c Rte_BlockM.c Rte_Did.c Rte_Fl_Cfg.c Rte_Job.c Rte_ProgCounter.c Rte_ResetJump.c Rte_SecM.c Rte_SegmentCheck.c
    ../src/mcal/Rte_TS_T01D20M1I4R0/src/: SchM_Base.c
    ../src/01_ProductCode/SecM/: SecM.c
    ../src/01_ProductCode/SecM/Algorithm/HASH256/: Sha_256.c
    ../src/mcal/Wdg_TS_T01D20M1I4R0/src/: Wdg.c Wdg_140_Instance1_Wdt.c Wdg_140_Instance2_Wdt.c Wdg_140_Instance3_Wdt.c Wdg_140_Instance4_Wdt.c Wdg_140_Instance5_Wdt.c Wdg_140_Instance6_Wdt.c Wdg_140_Instance8_Wdt.c Wdg_Hw_E3.c Wdg_Irq.c
    ../src/01_ProductCode/WdgIf/: WdgIf.c
