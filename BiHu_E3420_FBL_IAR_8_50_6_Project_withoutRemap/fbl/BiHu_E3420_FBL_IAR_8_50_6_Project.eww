<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BiHu_E3420_FBL_IAR_8_50_6_Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
